Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2023-10-31T15:36:58
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 31 15:36:58 2023 * Host: LAPTOP-RP8DN0OA * Database: C:\Users\claud\AppData\Local\Temp\{E04A3E7C-27D5-4521-922E-644433418282}\ifc * Database version: 5507 * Database creation date: Tue Oct 31 15:36:56 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 31 15:36:56 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 31 15:36:56 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 m
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey, 0 - Piano Terra
LongName: 0 - Piano Terra; Elevation: 0 m
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello: Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Altro - Categoria: Livelli; Famiglia: Livello: Livello; Famiglia e tipo: Livello: Livello; ID tipo: Livello: Livello; Tipo: Livello: Livello
Dati identità - Nome: 0 - Piano Terra; Piano edificio: yes; Strutturale: no
Dimensioni - Altezza di calcolo: 0 m
Vincoli - Quota altimetrica: 0 m
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Livello

# IfcBuildingElementProxy: 0PAAR060 - BUSH-HAMMERED, Panca HAPPY:0PAAR060 - BUSH-HAMMERED:212465
In: 0 - Piano Terra
Type - Material: GRANITO
Type - Altro - Categoria: Modelli generici; Nome famiglia: Panca HAPPY
Type - Dati identità - BIM Name: HAPPY; BIM Object Type: PANCHINE - BENCHES; Code: 0PAAR060; Designer: MATOUŠ HOLÝ; Family Name: ORGANIC COLLECTION; Nome del tipo: 0PAAR060 - BUSH-HAMMERED; URL Eng: https://www.bellitalia.net/en/products/benches/happy/; URL Ita: https://www.bellitalia.net/prodotti/panchine/happy/
Type - Dimensioni - Dimensions: 960 mm X 655 mm X h 383 mm X H 662 mm
Type - Generale - Descrizione Tecnica Famiglia: "Panca mod. “HAPPY” della linea ORGANIC, costituita da una seduta dalla geometria compatta e asimmetrica. La forma così irregolare invita a sedersi e la combinazione di più pezzi di queste scultoree poltrone trasforma gli spazi in salotti urbani da vivere."; Descrizione Tecnica per Codice: PANCA HAPPY IN GRANITO (COLORE A SCELTA) BOCCIARDATO CON PIANO DI SEDUTA LISCIO CASSERO VERNICIATURA ANTI-DEGRADO; Fissaggio: Appoggio; Fixings: freestanding; Technical Description Family: "HAPPY" mod. bench from the ORGANIC line, made up by a seat with a compact and asymmetrical geometry. The irregular shape invites you to sit down and there combination of several pieces of these sculptural armchairs transforms spaces into urban living rooms."; Technical Description for Article: HAPPY BENCH IN GRANITO (COLOR TO BE CHOSEN) BUSH-HAMMERED WITH SMOOTH FORMWORK SEAT SURFACE ANTI-DECAY VARNISH
Type - Materiali e finiture - Materiale Principale: Granito Bianco; Materiale Secondario: Granito Ricostituito; MATERIALE SEDUTA: GRANITO; Primary Material: White Granite; Secondary Material: Reconstituted Granite
Type - Meccanica - Weight ( kg): 505 Kg.
Pset_BuildingElementProxyCommon - Reference: 0PAAR060 - BUSH-HAMMERED
Altro - Famiglia: Panca HAPPY: 0PAAR060 - BUSH-HAMMERED; Famiglia e tipo: Panca HAPPY: 0PAAR060 - BUSH-HAMMERED; ID tipo: Panca HAPPY: 0PAAR060 - BUSH-HAMMERED; Tipo: Panca HAPPY: 0PAAR060 - BUSH-HAMMERED
Dimensioni - Area: 99.9677 m2; Volume: 190.644 m3
Fasi - Fase di creazione: Stato di Progetto
Vincoli - Host: Livello : 0 - Piano Terra; Livello: Livello: 0 - Piano Terra; Offset: 0 m; Sposta con l'oggetto più vicino: no
